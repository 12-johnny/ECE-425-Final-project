# Keil uVision project ECE425_FInal_Project_BOT.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECE425_FInal_Project_BOT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: SysTick_Delay.c GPIO.c Timer_0A_Interrupt.c PMOD_BTN_Interrupt.c PWM_Clock.c PWM0_0.c PWM1_3.c
  group inc
    ./: SysTick_Delay.h GPIO.h Timer_0A_Interrupt.h PMOD_BTN_Interrupt.h PWM_Clock.h PWM0_0.h PWM1_3.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
